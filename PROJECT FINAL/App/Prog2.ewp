# IAR project Prog2.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; BfrSize=35
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\BSP; ..\uCOS-III-Lib; ..\BSP\uCOS-III; ..\BSP\ST\STM32\inc; ..\..\Micrium\Software\uc-lib; ..\..\Micrium\Software\uC-CPU; ..\..\Micrium\Software\uC-CPU\ARM-Cortex-M3\IAR; ..\..\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\Micrium\Software\uCOS-III\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Prog3.out
  ILINK.IlinkIcfFile: ..\BSP\STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP/CFG
    ./: app_cfg.h os_cfg_app.h stm32f10x_conf.h
  group APP/Headers
    ../../: assert.h Intrpt.h
    ./: BfrPair.h Buffer.h Framer.h Globals.h includes.h MemMgr.h os_app_hooks.h PktParser.h Queue.h RobotControl.h RobotManager.h SerIODriver.h
  group APP/Source
    ../../prog4/App/: app_vect.c
    ./: BfrPair.c Buffer.c FinalProject.c Framer.c Intrpt.c MemMgr.c os_app_hooks.c PktParser.c Queue.c RobotControl.c RobotManager.c SerIODriver.c
  group BSP
    ./: STM32_FLASH.icf
  group BSP/Headers
    ../BSP/: bsp.h bsp_i2c.h bsp_ser.h bsp_stlm75.h
    ../BSP/uCOS-III/: bsp_os.h
  group BSP/Source
    ../BSP/: bsp.c bsp_i2c.c bsp_int.c bsp_periph.c bsp_ser.c bsp_stlm75.c
    ../BSP/uCOS-III/: bsp_os.c
  group BSP/STM32 Library/inc
    ../BSP/ST/STM32/INC/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/STM32 Library/src
    ../BSP/ST/STM32/SRC/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CFG - LIBRARIES
    ../uCOS-III-Lib/: cpu_cfg.h lib_cfg.h os_cfg.h os_type.h
  group uC/CPU/Headers
    ../../Micrium/Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
    ../../Micrium/Software/uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/Library
    ../uCOS-III-Lib/: uC-CPU-CM3-IAR.a
  group uC/LIB/Headers
    ../../Micrium/Software/uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Library
    ../uCOS-III-Lib/: uC-LIB-CM3-IAR.a
  group uC/OS-III
    ../../Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_dbg.c
  group uC/OS-III/Headers
    ../../Micrium/Software/uCOS-III/Source/: os.h
    ../../Micrium/Software/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h
  group uC/OS-III/Library
    ../uCOS-III-Lib/: uCOS-III-CM3-IAR.a
